# IAR project temperature_sensor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\inc\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: temperature_sensor.srec
  ILINK.IlinkOutputFile: temperature_sensor.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../../../../inc; ../../../../../inc/config
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: dialog14580.c DIALOG_SPI_M3025.c Readme_temperature_sensor.html
  group BLE Source
    ../../: ble_app_barebone_580.h BLE_code.h BLE_code_beacon.h BLE_code_paired.h sps_device_580.h sps_device_580_convertedTest.h sps_device_dialog.h sps_device_test.h
  group Source
    ../../src/dma/: adi_dma.c
    ../../src/gpio/: adi_gpio.c
    ../../src/i2c/: adi_i2c.c
    ../../src/pwr/: adi_pwr.c
    ../../src/spi/: adi_spi.c
    ../../src/uart/: adi_uart.c
    ../../src/wdt/: adi_wdt.c
    ../../: BLE.c ftoa.c temperature_sensor.c uart_command_handler.c
    ../../src/: common.c startup.c system.c
  group System
    ../: pinMuxBLE.c
